# IAR project elevator_control.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: PART_TM4C1294NCPDT; UART_BUFFERED; DEBUG
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.PreInclude: src\uart.h
  ICCARM.CCIncludePath2: ..\drivers; ..\..\TivaWare_C_Series-2.1.4.178; ..\..\CMSIS-5.6.0\CMSIS\Core\Include; ..\..\CMSIS-5.6.0\CMSIS\RTOS2\Include; ..\..\CMSIS-5.6.0\CMSIS\RTOS2\RTX\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..\..
  OBJCOPY.OOCOutputFile: elevator_control.bin
  ILINK.IlinkOutputFile: elevator_control.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    src/: command.c elevator.c elevator_thread.c fan_out_thread.c height_checker_thread.c kernel_info.c main.c main_thread.c RTX_Config.c rtx_lib.c signal.c signal_handler_thread.c startup_TM4C1294.s system_TM4C1294_TW.c uart.c
    ../../TivaWare_C_Series-2.1.4.178/driverlib/ewarm/Exe/: driverlib.a
    ../../CMSIS-5.6.0/CMSIS/RTOS2/RTX/Library/IAR/IDE/CM4F/Exe/: RTX_CM.a
    ../../TivaWare_C_Series-2.1.4.178/utils/: uartstdio.c
